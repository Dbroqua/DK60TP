# Repository Dbroqua/DK60TP

File README.md:

# Projet déplacé vers [framagit](https://framagit.org/mechkeyboards/DK60TP)

## KiCad design Kicad/DK60TP.kicad_pcb

Schematic: DK60TP.sch

Parts:
C1, C2: 22p; C_0805_HandSoldering
C3, C4, C5, C6: 0.1u; C_0805_HandSoldering
C7: 4.7u; C_0805_HandSoldering
C8: 1u; C_0805_HandSoldering
J1: USB_mini_micro_B; Micro_USB_Hand
M1, M2, M3, M4: MISC; BreakHoles_small
P1: MOUSE_BOARD; Molex_PicoBlade_53048-1010_10x1.25mm_Angled
R1, R2: 10K; R_0805_HandSoldering
R3, R4: 22; R_0805_HandSoldering
SW1: RESET; SW_SPST_TL3342
U0: ATMEGA32U4-MU; QFN-44-1EP_7x7mm_Pitch0.5mm
Y1: Crystal; Crystal_SMD_0603-2pin_6.0x3.5mm

Connections:
BACKLIT: U0.12 (PB7/~RTS); also elsewhere on the board
CAPS_LED: U0.1 (PE6/AIN0); also elsewhere on the board
Col0: U0.28 (PB4); also elsewhere on the board
Col1: U0.29 (PB5); also elsewhere on the board
Col2: U0.31 (PC6); also elsewhere on the board
Col3: P1.3, U0.36 (PF7); also elsewhere on the board
Col4: P1.4, U0.37 (PF6); also elsewhere on the board
Col5: U0.8 (PB0/SS); also elsewhere on the board
Col6: U0.10 (PB2/MOSI); also elsewhere on the board
Col7: U0.11 (PB3/MISO); also elsewhere on the board
Col8: P1.5, U0.40 (PF1); also elsewhere on the board
Col9: U0.39 (PF4); also elsewhere on the board
ColA: U0.21 (PD3/TXD1); also elsewhere on the board
ColB: U0.19 (PD1/INT1); also elsewhere on the board
ColC: U0.18 (PD0/INT0); also elsewhere on the board
ColD: U0.25 (ICP1/PD4); also elsewhere on the board
D2: P1.7, U0.20 (PD2/RXD1)
D5: P1.6, U0.22 (PD5/XCK1)
DOUT: P1.10; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J1.5 (GND), J1.6 (SHIELD), P1.2, R2.1, SW1.1, U0.5 (UGnd), U0.15 (GND), U0.23 (GND), U0.35 (GND), U0.43 (GND), U0.45 (GND); also elsewhere on the board
unnamed: C8.1, U0.6 (UCap)
unnamed: J1.2 (D-), R3.2
unnamed: J1.3 (D+), R4.2
unnamed: R2.2, U0.33 (~HWB/PE2)
unnamed: R3.1, U0.3 (D-)
unnamed: R4.1, U0.4 (D+)
RESET: R1.2, SW1.2, U0.13 (~RESET)
RGB: U0.26 (T1/PD6); also elsewhere on the board
Row0: U0.32 (PC7); also elsewhere on the board
Row1: U0.38 (PF5); also elsewhere on the board
Row2: U0.30 (PB6); also elsewhere on the board
Row3: U0.9 (PB1/SCK); also elsewhere on the board
Row4: P1.8, U0.27 (T0/PD7); also elsewhere on the board
VCC: C3.1, C4.1, C5.1, C6.1, C7.1, J1.1 (VUSB), P1.1, R1.1, U0.2 (UVcc), U0.7 (VBus), U0.14 (VCC), U0.24 (AVCC), U0.34 (VCC), U0.44 (AVCC); also elsewhere on the board
XTAL1: C1.1, U0.16 (XTAL1), Y1.1
XTAL2: C2.1, U0.17 (XTAL2), Y1.2

Notes on the sheet:
External sheets
Power decoupling
Reset
Clock
µControler
Split PCB holes
Trackpoint connector

Parts:
BL0, BL10, BL20, BL21, BL30, BL31, BL40, BL41, BL100, BL110, BL120, BL130, BL140, BL141, BL200, BL210, BL220, BL230, BL240, BL241, BL300, BL310, BL320, BL330, BL400, BL410, BL420, BL423, BL430, BL500, BL510, BL520, BL530, BL540, BL600, BL610, BL620, BL630, BL640, BL641, BL642, BL643, BL700, BL710, BL720, BL740, BL750, BL800, BL810, BL820, BL830, BL900, BL910, BL920, BL930, BL940: LED; LED_TH_BIVAR
BLA0, BLA10, BLA20, BLA30, BLA40, BLA41: LED; LED_TH_BIVAR
BLB0, BLB10, BLB20, BLB30, BLB40, BLB41, BLB42: LED; LED_TH_BIVAR
BLC0, BLC10, BLC20, BLC30, BLC31, BLC32, BLC40, BLC41: LED; LED_TH_BIVAR
BLD0, BLD1, BLD10, BLD20, BLD21, BLD22, BLD30, BLD31, BLD40, BLD41: LED; LED_TH_BIVAR
C10, C11: 10uF; C_0805_HandSoldering
L1: 4.7uH; Inductor_Bourn_4mmx4mm
R5: 0.5; R_0805_HandSoldering
U1: PAM2804; SOT-23-5

Connections:
BACKLIT: U1.1 (EN); also elsewhere on the board
GND: C10.1, C11.1, R5.1, U1.2 (GND); also elsewhere on the board
LED_AN: BL0.2 (A), BL10.2 (A), BL20.2 (A), BL21.2 (A), BL30.2 (A), BL31.2 (A), BL40.2 (A), BL41.2 (A), BL100.2 (A), BL110.2 (A), BL120.2 (A), BL130.2 (A), BL140.2 (A), BL141.2 (A), BL200.2 (A), BL210.2 (A), BL220.2 (A), BL230.2 (A), BL240.2 (A), BL241.2 (A), BL300.2 (A), BL310.2 (A), BL320.2 (A), BL330.2 (A), BL400.2 (A), BL410.2 (A), BL420.2 (A), BL423.2 (A), BL430.2 (A), BL500.2 (A), BL510.2 (A), BL520.2 (A), BL530.2 (A), BL540.2 (A), BL600.2 (A), BL610.2 (A), BL620.2 (A), BL630.2 (A), BL640.2 (A), BL641.2 (A), BL642.2 (A), BL643.2 (A), BL700.2 (A), BL710.2 (A), BL720.2 (A), BL740.2 (A), BL750.2 (A), BL800.2 (A), BL810.2 (A), BL820.2 (A), BL830.2 (A), BL900.2 (A), BL910.2 (A), BL920.2 (A), BL930.2 (A), BL940.2 (A), BLA0.2 (A), BLA10.2 (A), BLA20.2 (A), BLA30.2 (A), BLA40.2 (A), BLA41.2 (A), BLB0.2 (A), BLB10.2 (A), BLB20.2 (A), BLB30.2 (A), BLB40.2 (A), BLB41.2 (A), BLB42.2 (A), BLC0.2 (A), BLC10.2 (A), BLC20.2 (A), BLC30.2 (A), BLC31.2 (A), BLC32.2 (A), BLC40.2 (A), BLC41.2 (A), BLD0.2 (A), BLD1.2 (A), BLD10.2 (A)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
LED_CATH: BL0.1 (K), BL10.1 (K), BL20.1 (K), BL21.1 (K), BL30.1 (K), BL31.1 (K), BL40.1 (K), BL41.1 (K), BL100.1 (K), BL110.1 (K), BL120.1 (K), BL130.1 (K), BL140.1 (K), BL141.1 (K), BL200.1 (K), BL210.1 (K), BL220.1 (K), BL230.1 (K), BL240.1 (K), BL241.1 (K), BL300.1 (K), BL310.1 (K), BL320.1 (K), BL330.1 (K), BL400.1 (K), BL410.1 (K), BL420.1 (K), BL423.1 (K), BL430.1 (K), BL500.1 (K), BL510.1 (K), BL520.1 (K), BL530.1 (K), BL540.1 (K), BL600.1 (K), BL610.1 (K), BL620.1 (K), BL630.1 (K), BL640.1 (K), BL641.1 (K), BL642.1 (K), BL643.1 (K), BL700.1 (K), BL710.1 (K), BL720.1 (K), BL740.1 (K), BL750.1 (K), BL800.1 (K), BL810.1 (K), BL820.1 (K), BL830.1 (K), BL900.1 (K), BL910.1 (K), BL920.1 (K), BL930.1 (K), BL940.1 (K), BLA0.1 (K), BLA10.1 (K), BLA20.1 (K), BLA30.1 (K), BLA40.1 (K), BLA41.1 (K), BLB0.1 (K), BLB10.1 (K), BLB20.1 (K), BLB30.1 (K), BLB40.1 (K), BLB41.1 (K), BLB42.1 (K), BLC0.1 (K), BLC10.1 (K), BLC20.1 (K), BLC30.1 (K), BLC31.1 (K), BLC32.1 (K), BLC40.1 (K), BLC41.1 (K), BLD0.1 (K), BLD1.1 (K), BLD10.1 (K)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
unnamed: L1.1, U1.3 (SW)
VCC: C10.2, U1.4 (VIN); also elsewhere on the board

Notes on the sheet:
Backlit controler

Parts:
J3: CAPS_LOCK; Pin_Header_Angled_1x03_Pitch2.54mm
LD1: CAPS_LED; LED_PLCC_2835
R6: R; R_0805_HandSoldering

Connections:
CAPS_LED: R6.1; also elsewhere on the board
GND: J3.3, LD1.1 (K); also elsewhere on the board
unnamed: J3.1, R6.2
unnamed: J3.2, LD1.2 (A)

Parts:
C9: 2.2u; C_0805_HandSoldering
CRGB8, CRGB9, CRGB10: 0.1u; C_0805_HandSoldering
DK34: D43; D_SOD123
DK44: D44; D_SOD123
DK84: D48; D_SOD123
K340: LMB; Mx_100
K341: LMB; Mx_125
K440: MMB; Mx_100
K840: RMB; Mx_100
K841: RMB; Mx_125
P2: MAIN_BOARD; Molex_PicoBlade_53048-1010_10x1.25mm_Angled
P3: TRACKPOINT; Molex_PicoBlade_53048-0510_05x1.25mm_Angled
R7, R8: 4.7K; R_0805_HandSoldering
R9: 100K; R_0805_HandSoldering
RGB8, RGB9, RGB10: WS2812B

Connections:
/TRACKPOINT/Col3: DK34.2 (A), P2.3
/TRACKPOINT/Col4: DK44.2 (A), P2.4
/TRACKPOINT/Col8: DK84.2 (A), P2.5
/TRACKPOINT/D2: P2.7, P3.3, R8.2
/TRACKPOINT/D5: P2.6, P3.5, R7.2
/TRACKPOINT/RGB: P2.10, RGB8.4 (DIN)
/TRACKPOINT/Row4: K340.2, K341.2, K440.2, K840.2, K841.2, P2.8
GND: CRGB8.2, CRGB9.2, CRGB10.2, P2.2, P3.2, R9.2, RGB8.3 (VSS), RGB9.3 (VSS), RGB10.3 (VSS); also elsewhere on the board
unnamed: C9.1, P3.4, R9.1
unnamed: DK34.1 (K), K340.1, K341.1
unnamed: DK44.1 (K), K440.1
unnamed: DK84.1 (K), K840.1, K841.1
unnamed: RGB8.2 (DOUT), RGB9.4 (DIN)
unnamed: RGB9.2 (DOUT), RGB10.4 (DIN)
VCC: C9.2, CRGB8.1, CRGB9.1, CRGB10.1, P2.1, P3.1, R7.1, R8.1, RGB8.1 (VDD), RGB9.1 (VDD), RGB10.1 (VDD); also elsewhere on the board

Notes on the sheet:
Connector
Buttons
Trackpoint

Parts:
DK0: D00; D_SOD123
DK1: D10; D_SOD123
DK2: D20; D_SOD123
DK3: D30; D_SOD123
DK4: D40; D_SOD123
DK6: D60; D_SOD123
DK10: D01; D_SOD123
DK11: D11; D_SOD123
DK12: D21; D_SOD123
DK13: D31; D_SOD123
DK14: D41; D_SOD123
DK20: D02; D_SOD123
DK21: D12; D_SOD123
DK22: D22; D_SOD123
DK23: D32; D_SOD123
DK24: D42; D_SOD123
DK30: D03; D_SOD123
DK31: D13; D_SOD123
DK32: D23; D_SOD123
DK33: D33; D_SOD123
DK40: D04; D_SOD123
DK41: D14; D_SOD123
DK42: D24; D_SOD123
DK43: D34; D_SOD123
DK50: D05; D_SOD123
DK51: D15; D_SOD123
DK52: D25; D_SOD123
DK53: D35; D_SOD123
DK54: D45; D_SOD123
DK61: D16; D_SOD123
DK62: D26; D_SOD123
DK63: D36; D_SOD123
DK64: D46; D_SOD123
DK70: D07; D_SOD123
DK71: D17; D_SOD123
DK72: D27; D_SOD123
DK73: D37; D_SOD123
DK74: D47; D_SOD123
DK80: D08; D_SOD123
DK81: D18; D_SOD123
DK82: D28; D_SOD123
DK83: D38; D_SOD123
DK90: D09; D_SOD123
DK91: D19; D_SOD123
DK92: D29; D_SOD123
DK93: D39; D_SOD123
DK94: D49; D_SOD123
DKA0: D0A; D_SOD123
DKA1: DA1; D_SOD123
DKA2: D2A; D_SOD123
DKA3: D3A; D_SOD123
DKA4: D4A; D_SOD123
DKB0: D0B; D_SOD123
DKB1: D1B; D_SOD123
DKB2: D2B; D_SOD123
DKB3: D3B; D_SOD123
DKB4: D4B; D_SOD123
DKC1: D1C; D_SOD123
DKC2: D2C; D_SOD123
DKC3: D3C; D_SOD123
DKC4: D4C; D_SOD123
DKD0: DKD0; D_SOD123
DKD1: D1D; D_SOD123
DKD2: D2D; D_SOD123
DKD3: D3D; D_SOD123
DKD4: D4D; D_SOD123
K0: K00; Mx_100
K4C1: K4C; Mx_125
K10: K10; Mx_150
K20: K20; Mx_175
K21: K20; Mx_175_STEPPED
K30: K30; Mx_225
K31: K30; Mx_125
K40: K40; Mx_125
K41: K40; Mx_150
K100: K01; Mx_100
K110: K11; Mx_100
K120: K21; Mx_100
K130: K31; Mx_100
K140: K41; Mx_125
K141: K41; Mx_100
K142: K41; Mx_150
K200: K02; Mx_100
K210: K12; Mx_100
K220: K22; Mx_100
K230: K32; Mx_100
K240: K42; Mx_125
K241: K42; Mx_150
K300: K03; Mx_100
K310: K13; Mx_100
K320: K23; Mx_100
K330: K33; Mx_100
K400: K04; Mx_100
K410: K14; Mx_100
K420: K24; Mx_100
K430: K34; Mx_100
K500: K05; Mx_100
K510: K15; Mx_100
K520: K25; Mx_100
K530: K35; Mx_100
K540: K45; Mx_225
K600: K06; Mx_100
K610: K16; Mx_100
K620: K26; Mx_100
K630: K36; Mx_100
K640: K46; Mx_600
K641: K46; Mx_625
K642: K46; Mx_700
K643: K46; Mx_100
K700: K07; Mx_100
K710: K17; Mx_100
K720: K27; Mx_100
K730: K37; Mx_100
K740: K47; Mx_275
K800: K08; Mx_100
K810: K18; Mx_100
K820: K28; Mx_100
K830: K38; Mx_100
K900: K09; Mx_100
K910: K19; Mx_100
K920: K29; Mx_100
K930: K39; Mx_100
K940: K49; Mx_100
KA0: K0A; Mx_100
KA10: K1A; Mx_100
KA20: K2A; Mx_100
KA30: K3A; Mx_100
KA40: K4A; Mx_125
KA41: K4A; Mx_150
KB0: K0B; Mx_100
KB10: K1B; Mx_100
KB20: K2B; Mx_100
KB30: K3B; Mx_100
KB40: K4B; Mx_100
KB41: K4B; Mx_125
KB42: K4B; Mx_150
KC0: K0C; Mx_100
KC10: K1C; Mx_100
KC20: K2C; Mx_100
KC30: K3C; Mx_275
KC31: K3C; Mx_100
KC32: K3C; Mx_175
KC40: K4C; Mx_100
KD0: K0D; Mx_100
KD1: K0D; Mx_200
KD10: K1D; Mx_150
KD20: K2D; Mx_125
KD21: K2D; Mx_225
KD22: K2D; Mx_200
KD30: K3D; Mx_100
KD31: K3D; Mx_175
KD40: K4D; Mx_125
KD41: K4D; Mx_150
KDC0: D0C; D_SOD123

Connections:
Col0: DK0.2 (A), DK1.2 (A), DK2.2 (A), DK3.2 (A), DK4.2 (A); also elsewhere on the board
Col1: DK10.2 (A), DK11.2 (A), DK12.2 (A), DK13.2 (A), DK14.2 (A); also elsewhere on the board
Col2: DK20.2 (A), DK21.2 (A), DK22.2 (A), DK23.2 (A), DK24.2 (A); also elsewhere on the board
Col3: DK30.2 (A), DK31.2 (A), DK32.2 (A), DK33.2 (A); also elsewhere on the board
Col4: DK40.2 (A), DK41.2 (A), DK42.2 (A), DK43.2 (A); also elsewhere on the board
Col5: DK50.2 (A), DK51.2 (A), DK52.2 (A), DK53.2 (A), DK54.2 (A); also elsewhere on the board
Col6: DK6.2 (A), DK61.2 (A), DK62.2 (A), DK63.2 (A), DK64.2 (A); also elsewhere on the board
Col7: DK70.2 (A), DK71.2 (A), DK72.2 (A), DK73.2 (A), DK74.2 (A); also elsewhere on the board
Col8: DK80.2 (A), DK81.2 (A), DK82.2 (A), DK83.2 (A); also elsewhere on the board
Col9: DK90.2 (A), DK91.2 (A), DK92.2 (A), DK93.2 (A), DK94.2 (A); also elsewhere on the board
ColA: DKA0.2 (A), DKA1.2 (A), DKA2.2 (A), DKA3.2 (A), DKA4.2 (A); also elsewhere on the board
ColB: DKB0.2 (A), DKB1.2 (A), DKB2.2 (A), DKB3.2 (A), DKB4.2 (A); also elsewhere on the board
ColC: DKC1.2 (A), DKC2.2 (A), DKC3.2 (A), DKC4.2 (A), KDC0.2 (A); also elsewhere on the board
ColD: DKD0.2 (A), DKD1.2 (A), DKD2.2 (A), DKD3.2 (A), DKD4.2 (A); also elsewhere on the board
unnamed: DK0.1 (K), K0.1
unnamed: DK1.1 (K), K10.1
unnamed: DK2.1 (K), K20.1, K21.2
unnamed: DK3.1 (K), K30.1, K31.1
unnamed: DK4.1 (K), K40.1, K41.1
unnamed: DK6.1 (K), K600.1
unnamed: DK10.1 (K), K100.1
unnamed: DK11.1 (K), K110.1
unnamed: DK12.1 (K), K120.1
unnamed: DK13.1 (K), K130.1
unnamed: DK14.1 (K), K140.1, K141.1, K142.2
unnamed: DK20.1 (K), K200.1
unnamed: DK21.1 (K), K210.1
unnamed: DK22.1 (K), K220.1
unnamed: DK23.1 (K), K230.1
unnamed: DK24.1 (K), K240.1, K241.1
unnamed: DK30.1 (K), K300.1
unnamed: DK31.1 (K), K310.1
unnamed: DK32.1 (K), K320.1
unnamed: DK33.1 (K), K330.1
unnamed: DK40.1 (K), K400.1
unnamed: DK41.1 (K), K410.1
unnamed: DK42.1 (K), K420.1
unnamed: DK43.1 (K), K430.1
unnamed: DK50.1 (K), K500.1
unnamed: DK51.1 (K), K510.1
unnamed: DK52.1 (K), K520.1
unnamed: DK53.1 (K), K530.1
unnamed: DK54.1 (K), K540.1
unnamed: DK61.1 (K), K610.1
unnamed: DK62.1 (K), K620.1
unnamed: DK63.1 (K), K630.1
unnamed: DK64.1 (K), K640.1, K641.2, K642.2, K643.2
unnamed: DK70.1 (K), K700.1
unnamed: DK71.1 (K), K710.1
unnamed: DK72.1 (K), K720.1
unnamed: DK73.1 (K), K730.1
unnamed: DK74.1 (K), K740.1
unnamed: DK80.1 (K), K800.1
unnamed: DK81.1 (K), K810.1
unnamed: DK82.1 (K), K820.1
unnamed: DK83.1 (K), K830.1
unnamed: DK90.1 (K), K900.1
unnamed: DK91.1 (K), K910.1
unnamed: DK92.1 (K), K920.1
unnamed: DK93.1 (K), K930.1
unnamed: DK94.1 (K), K940.1
unnamed: DKA0.1 (K), KA0.1
unnamed: DKA1.1 (K), KA10.1
unnamed: DKA2.1 (K), KA20.1
unnamed: DKA3.1 (K), KA30.1
unnamed: DKA4.1 (K), KA40.1, KA41.1
unnamed: DKB0.1 (K), KB0.1
unnamed: DKB1.1 (K), KB10.1
unnamed: DKB2.1 (K), KB20.1
unnamed: DKB3.1 (K), KB30.1
unnamed: DKB4.1 (K), KB40.1, KB41.1, KB42.1
unnamed: DKC1.1 (K), KC10.1
unnamed: DKC2.1 (K), KC20.1
unnamed: DKC3.1 (K), KC30.1, KC31.1, KC32.1
unnamed: DKC4.1 (K), K4C1.1, KC40.1
unnamed: DKD0.1 (K), KD0.1, KD1.1
unnamed: DKD1.1 (K), KD10.1
unnamed: DKD2.1 (K), KD20.1, KD21.1, KD22.1
unnamed: DKD3.1 (K), KD30.2, KD31.1
unnamed: DKD4.1 (K), KD40.1, KD41.1
unnamed: KC0.1, KDC0.1 (K)
Row0: K0.2, K100.2, K200.2, K300.2, K400.2, K500.2, K600.2, K700.2, K800.2, K900.2, KA0.2, KB0.2, KC0.2, KD0.2, KD1.2; also elsewhere on the board
Row1: K10.2, K110.2, K210.2, K310.2, K410.2, K510.2, K610.2, K710.2, K810.2, K910.2, KA10.2, KB10.2, KC10.2, KD10.2; also elsewhere on the board
Row2: K20.2, K21.1, K120.2, K220.2, K320.2, K420.2, K520.2, K620.2, K720.2, K820.2, K920.2, KA20.2, KB20.2, KC20.2, KD20.2, KD21.2, KD22.2; also elsewhere on the board
Row3: K30.2, K31.2, K130.2, K230.2, K330.2, K430.2, K530.2, K630.2, K730.2, K830.2, K930.2, KA30.2, KB30.2, KC30.2, KC31.2, KC32.2, KD30.1, KD31.2; also elsewhere on the board
Row4: K4C1.2, K40.2, K41.2, K140.2, K141.2, K142.1, K240.2, K241.2, K540.2, K640.2, K641.1, K642.1, K643.1, K740.2, K940.2, KA40.2, KA41.2, KB40.2, KB41.2, KB42.2, KC40.2, KD40.2, KD41.2; also elsewhere on the board

Parts:
CRGB0, CRGB1, CRGB2, CRGB3, CRGB4, CRGB5, CRGB6, CRGB7: 0.1u; C_0805_HandSoldering
J2: RGB; Molex_PicoBlade_53048-0310_03x1.25mm_Angled
RGB0, RGB1, RGB2, RGB3, RGB4, RGB5, RGB6, RGB7: WS2812B

Connections:
DOUT: J2.3, RGB7.2 (DOUT); also elsewhere on the board
GND: CRGB0.2, CRGB1.2, CRGB2.2, CRGB3.2, CRGB4.2, CRGB5.2, CRGB6.2, CRGB7.2, J2.2, RGB0.3 (VSS), RGB1.3 (VSS), RGB2.3 (VSS), RGB3.3 (VSS), RGB4.3 (VSS), RGB5.3 (VSS), RGB6.3 (VSS), RGB7.3 (VSS); also elsewhere on the board
unnamed: RGB0.2 (DOUT), RGB1.4 (DIN)
unnamed: RGB1.2 (DOUT), RGB2.4 (DIN)
unnamed: RGB2.2 (DOUT), RGB3.4 (DIN)
unnamed: RGB3.2 (DOUT), RGB4.4 (DIN)
unnamed: RGB4.2 (DOUT), RGB5.4 (DIN)
unnamed: RGB5.2 (DOUT), RGB6.4 (DIN)
unnamed: RGB6.2 (DOUT), RGB7.4 (DIN)
RGB: RGB0.4 (DIN); also elsewhere on the board
VCC: CRGB0.1, CRGB1.1, CRGB2.1, CRGB3.1, CRGB4.1, CRGB5.1, CRGB6.1, CRGB7.1, J2.1, RGB0.1 (VDD), RGB1.1 (VDD), RGB2.1 (VDD), RGB3.1 (VDD), RGB4.1 (VDD), RGB5.1 (VDD), RGB6.1 (VDD), RGB7.1 (VDD); also elsewhere on the board

Parts:
6-6.25U_0: 6U/6.25U; MXST
6-7U_0: 6U/7U; MXST
6.25U_0: 6.25U; MXST
7U_0: 7U; MXST
7U_LEFT_0: 7U_LEFT_0; MXST
BACKSPACE_0, BACKSPACE_1: BACKSPACE; MXST
ENTER_ANSI_0, ENTER_ANSI_1: ENTER_ANSI; MXST
ENTER_ISO_0, ENTER_ISO_1: ENTER_ISO; MXST
L_SHIFT_0, L_SHIFT_1: L_SHIFT; MXST
MH1: MIDDLE_LEFT; Poker_side_edge_long
MH2: TOP_LEFT; MountingHole_2.5mm_Pad
MH3: CENTER; Poker_oval_hole
MH4: BOTTOM_RIGHT; Poker_oval_hole
MH5: TOP_RIGHT; Poker_oval_hole
MH6: MIDDLE_RIGHT; Poker_side_edge_long
MH7: TRACKPOINT; MountingHole_6mm
MH8: DARKOU-FRONT; darkou
MH9: DARKOU-BACK; darkou
MH10: OpenHardware; OPEN-HARDWARE
MH11: MB_LEFT; Poker_oval_hole
MH12: MB_CENTER; Poker_oval_hole
MH13: MB_RIGHT; Poker_oval_hole
R_SHIFT_0, R_SHIFT_1: R_SHIFT; MXST
SPC_275_0: SPC_275_0; MXST
SPC_R_SPLIT_0: SPC_275_0; MXST
SPC_R_SPLIT_1: SPC_275_1; MXST

Notes on the sheet:
Holes
Logos
Mouse buttons PCB

Board: 2 copper layers, 285.0 x 113.5 mm, 338 parts (125 on the bottom side), 128 nets.

## Commit log

2017-06-14 - Initial commit
2017-06-14 - Fixed bug in README
2017-06-14 - Minor text change in case file
2017-06-15 - Added Trackpoint previews
2017-06-16 - Added documentation for WS2812
2017-06-16 - Added documentation for SK6812RGBW
2017-06-16 - Cleaning useless file and updated routing
2017-06-17 - Minor change on routing
2017-06-17 - Updated dimensions for Base trackpoint
2017-06-19 - Added documentation for MOLEX connectors
2017-06-19 - Updated routing
2017-06-28 - Updated 3 pin header for caps lock
2017-06-29 - Updated PCB previews
2017-06-29 - Added GERBER files
2017-07-02 - Env changes
2017-07-10 - Added RGB connector pinout
2017-07-11 - FIxed bug in wiring (missing connections)
2017-07-11 - Updated External led chapter
2017-07-13 - Updated documentation for external components
2017-07-16 - Added holes for trackpoint fixations
2017-10-03 - Added documentation for 2 channel relay
2017-10-05 - Added transistor documentation
2017-10-07 - Added ME9926 (Dual N-Channel 20V (D-S) MOSFET)
2017-10-07 - Added some footprint dimensions
2017-10-07 - Updated page format
2017-10-07 - Fixed hole position
2017-10-07 - Updated number of holes...
2017-10-07 - Added grid size reference
2017-10-07 - Kicad tips
2017-10-07 Formatting list
    Fixed bug for the sub list in kicad tips section
2017-10-08 - Removed some holes
2017-10-08 - First draw for Rev. B
2017-10-09 - Removed Gerber from Rev. A
2017-10-09 - Updated ATMEGA to MU version
2017-10-09 - Updated previews
2017-10-09 - Updated ATMEGA controller (AU and MU package)
2017-10-09 - Simplifying routage (1 over n)
2017-10-09 - Simplifying routing (2/n) + fixed bug for RShift
2017-10-10 - Removed old gerber archive
2017-10-10 - Added other breakholes design
2017-10-10 - Simplifying routing (3/n)
2017-10-11 - Simplifying routing (4/n)
2017-10-11 - First commit for splitted spacebar
2017-10-12 - Added Splitted spacebar
2017-10-13 - Routing and moved components near holes
2017-10-13 Added new extesion
    New design, thinner than the original revision.
2017-10-13 Updated file
    3x3 design
2017-10-13 - Added printer extension
    Just a preview of printed extensions. Final parts will only contains 9
    extensions.
2017-10-13 Reduced size of connections
2017-10-13 Removed values/references on PCB
2017-10-13 Routing
2017-10-14 - Added ABM77 crystal datasheet
2017-10-14 Changed Crystal
    Replaced crystal with 2 poles crystal
2017-10-14 Removed useless libraries
    Merging all components in one library file to simplify maintenance
2017-10-15 Routing / Filled zone
    - Cleaning routing
    - Increase filled zone for B layer
2017-10-16 - Fixed bug for caps lock
2017-10-16 - Increased GND area
2017-10-17 - Some changes (routing/ground area/space)
    - Updated routing
    - Increased ground area
    - Invert Split space 2.75U/2.25U
    - Added missing led for backlit
2017-10-17 - Increased GND area on front layer
2017-10-18 - Added documentation for Micro USB
2017-10-18 - Added footprint for Micro USB with hand solder
2017-10-18 - Changed USB Mini to USB Micro
2017-10-18 - Added Micro USB footprint
2017-10-18 - Updated Micro USB Hand footprint
2017-10-18 Moved library and footprint to is own repo
2017-10-19 Fixed position of the USB port
2017-10-19 - Increase GND area on Front layer
2017-10-19 Removed BOM file exclusion
2017-10-19 - Removed useless lib
2017-10-19 - Updated som manf# for mouser
2017-10-19 Added BOM csv and xml files
2017-10-21 - Increased GND areas
2017-10-21 - Fixed some bugs
    * Fixed bug when trying to show 3D Viewer (bad egde cuts)
    * Updated GND areas
    * Fixed error when loading net list (bad chip name for holes)
2017-10-22 - Updated doc for Cherry MX circuit board
2017-10-22 - Added ivan ivanovitch layout
2017-10-22 - Added missing led for ivan ivanovitch layout
2017-10-23 Updated wiring
    Swap RGB and Row4 pins
2017-10-24 Moved pin headers
    Moved capslock pins, RGB extension plug and Mouse board plug
2017-10-26 Updated KLE preview
2017-10-27 Removed some Vias
2017-10-27 Reduced VIAs quantity
2017-10-28 Reduced useless VIAs quantity
2017-10-28 Less than 100 VIAs!
    Inverted col8 and col9 on Atmega to reduce the quantity of VIAs.
2017-10-29 Added 2 break holes and updated renders
    * Added 2 break holes to increase solidity in case of the user wont
    seperate the 2 parts
    * Removed some 3D Shape to have a better render view
2017-11-05 Reduced VIAs
2017-12-24 Little change in route width
2017-12-24 Routing, again
2018-02-21 Small update for vias
