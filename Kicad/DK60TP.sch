File: Kicad/DK60TP.sch (KiCad schematic (older format))
At the start: 19 parts, among them J1 USB_mini_micro_B, M1 MISC, M2 MISC, P1 MOUSE_BOARD, SW1 SW_PUSH, U0 ATMEGA32U4-MU, X1 XTAL_GND

Commit message: - First commit for splitted spacebar
Changed lines of the file:
@@
 $EndComp
 $Comp
-L GND #PWR01
+L GND #PWR14
 U 1 1 5904AF3A
 P 7200 4800
-F 0 "#PWR01" H 7200 4550 50  0001 C CNN
+F 0 "#PWR14" H 7200 4550 50  0001 C CNN
 F 1 "GND" H 7200 4650 50  0000 C CNN
 F 2 "" H 7200 4800 50  0001 C CNN
@@
 $EndComp
 $Comp
-L VCC #PWR02
+L VCC #PWR3
 U 1 1 5904B57E
 P 1900 4150
-F 0 "#PWR02" H 1900 4000 50  0001 C CNN
+F 0 "#PWR3" H 1900 4000 50  0001 C CNN
 F 1 "VCC" H 1900 4300 50  0000 C CNN
 F 2 "" H 1900 4150 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR03
+L GND #PWR4
 U 1 1 5904B906
 P 1900 4600
-F 0 "#PWR03" H 1900 4350 50  0001 C CNN
+F 0 "#PWR4" H 1900 4350 50  0001 C CNN
 F 1 "GND" H 1900 4450 50  0000 C CNN
 F 2 "" H 1900 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L VCC #PWR04
+L VCC #PWR6
 U 1 1 5904C66A
 P 3200 4150
-F 0 "#PWR04" H 3200 4000 50  0001 C CNN
+F 0 "#PWR6" H 3200 4000 50  0001 C CNN
 F 1 "VCC" H 3200 4300 50  0000 C CNN
 F 2 "" H 3200 4150 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR05
+L GND #PWR7
 U 1 1 5904C8AA
 P 3200 4600
-F 0 "#PWR05" H 3200 4350 50  0001 C CNN
+F 0 "#PWR7" H 3200 4350 50  0001 C CNN
 F 1 "GND" H 3200 4450 50  0000 C CNN
 F 2 "" H 3200 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR06
+L GND #PWR11
 U 1 1 5904D1CD
 P 5150 2600
-F 0 "#PWR06" H 5150 2350 50  0001 C CNN
+F 0 "#PWR11" H 5150 2350 50  0001 C CNN
 F 1 "GND" H 5150 2450 50  0000 C CNN
 F 2 "" H 5150 2600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L VCC #PWR07
+L VCC #PWR1
 U 1 1 5920545A
 P 1800 850
-F 0 "#PWR07" H 1800 700 50  0001 C CNN
+F 0 "#PWR1" H 1800 700 50  0001 C CNN
 F 1 "VCC" H 1800 1000 50  0000 C CNN
 F 2 "" H 1800 850 50  0001 C CNN
@@
 B
 $Comp
-L GND #PWR08
+L GND #PWR8
 U 1 1 593106C4
 P 4850 950
-F 0 "#PWR08" H 4850 700 50  0001 C CNN
+F 0 "#PWR8" H 4850 700 50  0001 C CNN
 F 1 "GND" H 4850 800 50  0000 C CNN
 F 2 "" H 4850 950 50  0001 C CNN
@@
 $EndSheet
 $Comp
-L GND #PWR09
+L GND #PWR5
 U 1 1 59349AA8
 P 2800 3350
-F 0 "#PWR09" H 2800 3100 50  0001 C CNN
+F 0 "#PWR5" H 2800 3100 50  0001 C CNN
 F 1 "GND" H 2800 3200 50  0000 C CNN
 F 2 "" H 2800 3350 50  0001 C CNN
@@
 F0 "TRACKPOINT" 60
 F1 "TRACKPOINT.sch" 60
-F2 "Col5" I L 5550 1600 60
+F2 "Col8" I L 5550 1600 60
 F3 "Col4" I L 5550 1700 60
 F4 "Col3" I L 5550 1800 60
@@
 Row3
 $Comp
-L GND #PWR010
+L GND #PWR9
 U 1 1 593621F1
 P 4900 1750
-F 0 "#PWR010" H 4900 1500 50  0001 C CNN
+F 0 "#PWR9" H 4900 1500 50  0001 C CNN
 F 1 "GND" H 4900 1600 50  0000 C CNN
 F 2 "" H 4900 1750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L VCC #PWR011
+L VCC #PWR12
 U 1 1 593B1C08
 P 5250 800
-F 0 "#PWR011" H 5250 650 50  0001 C CNN
+F 0 "#PWR12" H 5250 650 50  0001 C CNN
 F 1 "VCC" H 5250 950 50  0000 C CNN
 F 2 "" H 5250 800 50  0001 C CNN
@@
 RESET
 $Comp
-L VCC #PWR012
+L VCC #PWR2
 U 1 1 59395D72
 P 1800 1750
-F 0 "#PWR012" H 1800 1600 50  0001 C CNN
+F 0 "#PWR2" H 1800 1600 50  0001 C CNN
 F 1 "VCC" H 1800 1900 50  0000 C CNN
 F 2 "" H 1800 1750 50  0001 C CNN
@@
 Row4
 $Comp
-L GND #PWR013
+L GND #PWR13
 U 1 1 593CBEF2
 P 6250 4500
-F 0 "#PWR013" H 6250 4250 50  0001 C CNN
+F 0 "#PWR13" H 6250 4250 50  0001 C CNN
 F 1 "GND" H 6250 4350 50  0000 C CNN
 F 2 "" H 6250 4500 50  0001 C CNN
@@
 $EndComp
 $Comp
-L VCC #PWR014
+L VCC #PWR10
 U 1 1 593CBBEA
 P 5000 4100
-F 0 "#PWR014" H 5000 3950 50  0001 C CNN
+F 0 "#PWR10" H 5000 3950 50  0001 C CNN
 F 1 "VCC" H 5000 4250 50  0000 C CNN
 F 2 "" H 5000 4100 50  0001 C CNN

Commit message: - Added Splitted spacebar
Connections:
- net Col0: now also U0.28 (PB4); no longer U0.36 (PF7)
- net Col1: now also U0.29 (PB5); no longer U0.38 (PF5)
- net Col2: now also U0.31 (PC6); no longer U0.39 (PF4)
- net Col3: now also U0.36 (PF7); no longer U0.40 (PF1)
- net Col4: now also U0.37 (PF6); no longer U0.30 (PB6)
- net Col5: no longer P1.5 (P5)
- net Col8: now also P1.5 (P5), U0.39 (PF4); no longer U0.26 (T1/PD6)
- net Col9: now also U0.40 (PF1); no longer U0.28 (PB4)
- net Row0: now also U0.32 (PC7); no longer U0.37 (PF6)
- net Row1: now also U0.38 (PF5); no longer U0.31 (PC6)
- net Row2: now also U0.30 (PB6); no longer U0.29 (PB5)
- net Row4: now also U0.26 (T1/PD6); no longer U0.32 (PC7)
Changed lines of the file:
@@
 $EndComp
 $Comp
-L GND #PWR14
+L GND #PWR01
 U 1 1 5904AF3A
 P 7200 4800
-F 0 "#PWR14" H 7200 4550 50  0001 C CNN
+F 0 "#PWR01" H 7200 4550 50  0001 C CNN
 F 1 "GND" H 7200 4650 50  0000 C CNN
 F 2 "" H 7200 4800 50  0001 C CNN
@@
 $EndComp
 $Comp
-L VCC #PWR3
+L VCC #PWR02
 U 1 1 5904B57E
 P 1900 4150
-F 0 "#PWR3" H 1900 4000 50  0001 C CNN
+F 0 "#PWR02" H 1900 4000 50  0001 C CNN
 F 1 "VCC" H 1900 4300 50  0000 C CNN
 F 2 "" H 1900 4150 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR4
+L GND #PWR03
 U 1 1 5904B906
 P 1900 4600
-F 0 "#PWR4" H 1900 4350 50  0001 C CNN
+F 0 "#PWR03" H 1900 4350 50  0001 C CNN
 F 1 "GND" H 1900 4450 50  0000 C CNN
 F 2 "" H 1900 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L VCC #PWR6
+L VCC #PWR04
 U 1 1 5904C66A
 P 3200 4150
-F 0 "#PWR6" H 3200 4000 50  0001 C CNN
+F 0 "#PWR04" H 3200 4000 50  0001 C CNN
 F 1 "VCC" H 3200 4300 50  0000 C CNN
 F 2 "" H 3200 4150 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR7
+L GND #PWR05
 U 1 1 5904C8AA
 P 3200 4600
-F 0 "#PWR7" H 3200 4350 50  0001 C CNN
+F 0 "#PWR05" H 3200 4350 50  0001 C CNN
 F 1 "GND" H 3200 4450 50  0000 C CNN
 F 2 "" H 3200 4600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR11
+L GND #PWR06
 U 1 1 5904D1CD
 P 5150 2600
-F 0 "#PWR11" H 5150 2350 50  0001 C CNN
+F 0 "#PWR06" H 5150 2350 50  0001 C CNN
 F 1 "GND" H 5150 2450 50  0000 C CNN
 F 2 "" H 5150 2600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L VCC #PWR1
+L VCC #PWR07
 U 1 1 5920545A
 P 1800 850
-F 0 "#PWR1" H 1800 700 50  0001 C CNN
+F 0 "#PWR07" H 1800 700 50  0001 C CNN
 F 1 "VCC" H 1800 1000 50  0000 C CNN
 F 2 "" H 1800 850 50  0001 C CNN
@@
 B
 $Comp
-L GND #PWR8
+L GND #PWR08
 U 1 1 593106C4
 P 4850 950
-F 0 "#PWR8" H 4850 700 50  0001 C CNN
+F 0 "#PWR08" H 4850 700 50  0001 C CNN
 F 1 "GND" H 4850 800 50  0000 C CNN
 F 2 "" H 4850 950 50  0001 C CNN
@@
 $EndSheet
 $Comp
-L GND #PWR5
+L GND #PWR09
 U 1 1 59349AA8
 P 2800 3350
-F 0 "#PWR5" H 2800 3100 50  0001 C CNN
+F 0 "#PWR09" H 2800 3100 50  0001 C CNN
 F 1 "GND" H 2800 3200 50  0000 C CNN
 F 2 "" H 2800 3350 50  0001 C CNN
@@
 Text GLabel 2500 1550 0    60   Input ~ 0
 Col5
-Text GLabel 4650 2250 2    60   Input ~ 0
+Text GLabel 4650 1550 2    60   Input ~ 0
 Col4
-Text GLabel 4650 1250 2    60   Input ~ 0
+Text GLabel 4650 1650 2    60   Input ~ 0
 Col3
-Text GLabel 4650 2050 2    60   Input ~ 0
+Text GLabel 4650 2650 2    60   Input ~ 0
 Row4
-Text GLabel 4650 1650 2    60   Input ~ 0
+Text GLabel 4650 2450 2    60   Input ~ 0
 Col0
-Text GLabel 4650 1450 2    60   Input ~ 0
+Text GLabel 4650 2350 2    60   Input ~ 0
 Col1
-Text GLabel 4650 1350 2    60   Input ~ 0
+Text GLabel 4650 2150 2    60   Input ~ 0
 Col2
 Text GLabel 2500 1750 0    60   Input ~ 0
@@
 Text GLabel 2500 1850 0    60   Input ~ 0
 Col7
-Text GLabel 4650 2650 2    60   Input ~ 0
+Text GLabel 4650 1350 2    60   Input ~ 0
 Col8
-Text GLabel 4650 2450 2    60   Input ~ 0
+Text GLabel 4650 1250 2    60   Input ~ 0
 Col9
 Text GLabel 2500 2850 0    60   Input ~ 0
@@
 Text GLabel 4650 2750 2    60   Input ~ 0
 ColD
-Text GLabel 4650 1550 2    60   Input ~ 0
+Text GLabel 4650 2050 2    60   Input ~ 0
 Row0
-Text GLabel 4650 2150 2    60   Input ~ 0
+Text GLabel 4650 1450 2    60   Input ~ 0
 Row1
-Text GLabel 4650 2350 2    60   Input ~ 0
+Text GLabel 4650 2250 2    60   Input ~ 0
 Row2
 Text GLabel 2500 1650 0    60   Input ~ 0
 Row3
 $Comp
-L GND #PWR9
+L GND #PWR010
 U 1 1 593621F1
 P 4900 1750
-F 0 "#PWR9" H 4900 1500 50  0001 C CNN
+F 0 "#PWR010" H 4900 1500 50  0001 C CNN
 F 1 "GND" H 4900 1600 50  0000 C CNN
 F 2 "" H 4900 1750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L VCC #PWR12
+L VCC #PWR011
 U 1 1 593B1C08
 P 5250 800
-F 0 "#PWR12" H 5250 650 50  0001 C CNN
+F 0 "#PWR011" H 5250 650 50  0001 C CNN
 F 1 "VCC" H 5250 950 50  0000 C CNN
 F 2 "" H 5250 800 50  0001 C CNN
@@
 RESET
 $Comp
-L VCC #PWR2
+L VCC #PWR012
 U 1 1 59395D72
 P 1800 1750
-F 0 "#PWR2" H 1800 1600 50  0001 C CNN
+F 0 "#PWR012" H 1800 1600 50  0001 C CNN
 F 1 "VCC" H 1800 1900 50  0000 C CNN
 F 2 "" H 1800 1750 50  0001 C CNN
@@
 $EndComp
 Text GLabel 5100 4400 0    60   Input ~ 0
-Col5
+Col8
 Text GLabel 5600 4300 2    60   Input ~ 0
 Col4
@@
 Row4
 $Comp
-L GND #PWR13
+L GND #PWR013
 U 1 1 593CBEF2
 P 6250 4500
-F 0 "#PWR13" H 6250 4250 50  0001 C CNN
+F 0 "#PWR013" H 6250 4250 50  0001 C CNN
 F 1 "GND" H 6250 4350 50  0000 C CNN
 F 2 "" H 6250 4500 50  0001 C CNN
@@
 $EndComp
 $Comp
-L VCC #PWR10
+L VCC #PWR014
 U 1 1 593CBBEA
 P 5000 4100
-F 0 "#PWR10" H 5000 3950 50  0001 C CNN
+F 0 "#PWR014" H 5000 3950 50  0001 C CNN
 F 1 "VCC" H 5000 4250 50  0000 C CNN
 F 2 "" H 5000 4100 50  0001 C CNN

Commit message: Changed Crystal
Replaced crystal with 2 poles crystal
Parts:
- removed X1: XTAL_GND, Footprint:FA-238, symbol XTAL_GND
- added Y1: Crystal, Crystals:Crystal_SMD_0603-2pin_6.0x3.5mm, symbol Crystal
- SW1: value SW_PUSH -> RESET
Connections:
- net XTAL1: now also Y1.1
- net XTAL2: now also Y1.2
Changed lines of the file:
@@
 EESchema Schematic File Version 2
+LIBS:74xgxx
+LIBS:74xx
+LIBS:ac-dc
+LIBS:actel
+LIBS:adc-dac
+LIBS:allegro
+LIBS:Altera
+LIBS:analog_devices
+LIBS:analog_switches
+LIBS:audio
+LIBS:battery_management
+LIBS:bbd
+LIBS:bosch
+LIBS:brooktre
+LIBS:cmos4000
+LIBS:cmos_ieee
+LIBS:conn
+LIBS:contrib
+LIBS:cypress
+LIBS:dc-dc
+LIBS:device
+LIBS:digital-audio
+LIBS:diode
+LIBS:display
+LIBS:dsp
+LIBS:elec-unifil
+LIBS:ESD_Protection
+LIBS:ftdi
+LIBS:gennum
+LIBS:graphic_symbols
+LIBS:hc11
+LIBS:infineon
+LIBS:intel
+LIBS:interface
+LIBS:intersil
+LIBS:ir
+LIBS:Lattice
+LIBS:leds
+LIBS:LEM
+LIBS:linear
+LIBS:logic_programmable
+LIBS:maxim
+LIBS:mechanical
+LIBS:memory
+LIBS:microchip
+LIBS:microchip_dspic33dsc
+LIBS:microchip_pic10mcu
+LIBS:microchip_pic12mcu
+LIBS:microchip_pic16mcu
+LIBS:microchip_pic18mcu
+LIBS:microchip_pic24mcu
+LIBS:microchip_pic32mcu
+LIBS:microcontrollers
+LIBS:modules
+LIBS:motor_drivers
+LIBS:motorola
+LIBS:motors
+LIBS:msp430
+LIBS:nordicsemi
+LIBS:nxp
+LIBS:nxp_armmcu
+LIBS:onsemi
+LIBS:opto
+LIBS:Oscillators
+LIBS:philips
 LIBS:power
+LIBS:powerint
+LIBS:Power_Management
+LIBS:pspice
+LIBS:references
+LIBS:regul
+LIBS:relays
+LIBS:rfcom
+LIBS:RFSolutions
+LIBS:sensors
+LIBS:silabs
+LIBS:siliconi
+LIBS:stm8
+LIBS:stm32
+LIBS:supertex
+LIBS:switches
+LIBS:texas
+LIBS:transf
+LIBS:transistors
+LIBS:triac_thyristor
+LIBS:ttl_ieee
+LIBS:valves
+LIBS:video
+LIBS:wiznet
+LIBS:Xicor
+LIBS:xilinx
+LIBS:zetex
+LIBS:Zilog
+LIBS:keyboard_parts
+LIBS:mkl27z256vfm4
+LIBS:Trackpad
+LIBS:TS65
 LIBS:DK60TP-cache
 EELAYER 25 0
@@
 $EndDescr
 $Comp
-L XTAL_GND X1
-U 1 1 5904AD34
-P 7200 4350
-F 0 "X1" H 7200 4500 60  0000 C CNN
-F 1 "XTAL_GND" H 7200 4200 60  0000 C CNN
-F 2 "Footprint:FA-238" H 7200 4350 60  0001 C CNN
-F 3 "" H 7200 4350 60  0000 C CNN
-	1    7200 4350
-	1    0    0    -1
-$EndComp
-$Comp
 L C_Small C1
 U 1 1 5904ADE4
@@
 P 3650 4550
 F 0 "SW1" H 3800 4660 50  0000 C CNN
-F 1 "SW_PUSH" H 3650 4470 50  0000 C CNN
+F 1 "RESET" H 3650 4470 50  0000 C CNN
 F 2 "Buttons_Switches_SMD:SW_SPST_TL3342" H 3650 4550 60  0001 C CNN
 F 3 "" H 3650 4550 60  0000 C CNN
@@
 	600  550  600  3600
 Wire Wire Line
-	7500 4350 7650 4350
+	7350 4350 7650 4350
 Connection ~ 7650 4350
 Wire Wire Line
-	6900 4350 6750 4350
+	6750 4350 7050 4350
 Connection ~ 6750 4350
 Wire Wire Line
@@
 Wire Wire Line
 	7650 4750 7650 4650
-Wire Wire Line
-	7200 4550 7200 4800
 Connection ~ 7200 4750
 Wire Notes Line
@@
 	3800 3250 3800 3350
 Connection ~ 3800 3350
+$Comp
+L Crystal Y1
+U 1 1 59E2052B
+P 7200 4350
+F 0 "Y1" H 7200 4500 50  0000 C CNN
+F 1 "Crystal" H 7200 4200 50  0000 C CNN
+F 2 "Crystals:Crystal_SMD_0603-2pin_6.0x3.5mm" H 7200 4350 50  0001 C CNN
+F 3 "http://www.abracon.com/Resonators/abm7.pdf" H 7200 4350 50  0001 C CNN
+F 4 "ABM7-16.000MHZ-D2Y-T" H 7200 4350 60  0001 C CNN "manf#"
+	1    7200 4350
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	7200 4750 7200 4800
 $EndSCHEMATC
